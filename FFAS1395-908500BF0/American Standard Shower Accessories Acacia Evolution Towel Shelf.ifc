Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-01T14:58:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Alternate UI 21.1.21.45
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 01 14:58:17 2021 * Host: LAPTOP-GL8UO08N * Database: C:\Users\CHATPONG\AppData\Local\Temp\c659df10-31cd-47a7-b1e1-1a342466ce69\c5d279c8-b6d0-4681-a4d3-12dd2037dc8e\ifc * Database version: 5507 * Database creation date: Fri Oct 01 14:58:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 01 14:58:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 01 14:58:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: Acacia Evolution Towel Shelf_FFAS1395-908500BF0:Acacia Evolution Towel Shelf_FFAS1395-908500BF0, Acacia Evolution Towel Shelf_FFAS1395-908500BF0:Acacia Evolution Towel Shelf_FFAS1395-908500BF0:359008
In: Level 1
Type - Material: Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Name: Towel Shelf; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia Evolution Towel Shelf_FFAS1395-908500BF0
Pset_DistributionFlowElementCommon - Reference: Acacia Evolution Towel Shelf_FFAS1395-908500BF0; sets with these values: 2
